Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-18T15:23:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 18 15:23:31 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{125CC73A-D2E3-44E0-B18F-9FDC9AC0AB49}\ifc* Database version: 5507* Database creation date: Wed Jan 18 15:23:30 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 18 15:23:31 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 18 15:23:31 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Gartec Ltd_17666\NBLA0684\Authoring\IFC\NBS_GartecLtd_VrtclLftngPltfrms_Artico7000PlatformLift_ThroughCarDoors-ShortTravelDistance.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcTransportElement: LeftRightAccess_900x1040mm, NBS_GartecLtd_VrtclLftngPltfrms_Artico7000PlatformLift_ThroughCarDoors-ShortTravelDistance:LeftRightAccess_900x1040mm:53025
In: Level 1
Type - PredefinedType: ELEVATOR; Classification: Pr_65_80_47_95 (Uniclass2015); Material: NBS_Concept, NBS_Mirror, NBS_Glass_Single
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GartecLtd_VerticalLiftingPlatforms_Artico7000PlatformLift_ThroughCarDoors-ShortTravelDistance-900x1040mm; ManufacturerName: Gartec Ltd; ManufacturerURL: www.gartec.com; NBSCertification: www.nationalbimlibrary.com/cert/n4xy4dqu; NBSDescription: Vertical lifting platforms; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 90-80-65/350; NBSTypeID: n/a; ProductInformation: www.gartec.com/aritco-7000/; Revision: n/a; Uniclass2015Code: Pr_65_80_47_95; Uniclass2015Title: Vertical lifting platforms; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Shaft lighting, emergency lighting on platform, optional emergency lighting on ceiling), intercom as standard, optional fold down seat; Capacity: 410-500 kg (3 phase required); CarrierControlFeaturesFinish: Natural anodised aluminim with coloured text; CarrierControlFeaturesFormat: Illuminated constant pressure buttons on platform, Arrival sounder, Destination, alarm and emergency stop buttons; CarrierControlFeaturesMaterial: Aluminium face plate; CarrierFinish: n/a; CarrierFloorCovering: Anti-slip vinyl; CarrierFloorCoveringOptions: 6 Vinyl colours available as standard, rubber, aluminium finish; CarrierFormat: Open platform; CarrierHandRailsFinish: Brushed; CarrierHandRailsFormat: Ends angled toward wall; CarrierHandRailsLocation: One side on console; CarrierHandRailsMaterial: Aluminium; CarrierMaterial: Galvanized low carbon steel; Certification: CE Marked in accordance with the Revised Machinery Directive (2006/42/EC) and EN81-41; DoorsArrangement: Through; DoorsClearOpeningWidthMinimum: 900 mm; DoorsFireRating: n/a; DoorsFrameFinish: Powder coated; DoorsFrameMaterial: Integral to shaft enclosure; DoorsInfill: GL half glass at lower landings, half height door at top landing; DoorsInfillFinish: Powder coated; DoorsOperation: Swing door with closer; DriveType: Stationary screw and rotating nut; DutyCycle: 20 (maximum); ElectricalSupply: 230 V, 1 phase, 20 A, 50 HZ; EnclosureFireRating: n/a; EnclosureFormat: Free standing, mast support required to one long side; EnclosureFrameFinish: Powder Coated; EnclosureFrameMaterialComposition: Galvanized low carbon steel and aluminium , Low carbon steel; EnclosureInfill: White vinyl coated double skinned steel panels filled with EPS polystyrene as standard; EnclosureInfillFinish: n/a; EnclosureInfillOptions: White vinyl coated double skinned steel panels filled with EPS polystyrene, Toughened and laminated glass panels with glass sizes up to 2500 mm,; Environment: Indoor or Outdoor; LandingControlsCallStations: One touch buttons; LandingControlsFeatures: Tactile and illuminated operational buttons , Lockable isolator within 2 metres and in view of electrical cabinet located at the upper landing, Battery back up, School locking facility; MachineRoom: Integral to enclosure; Motor: 2.2 kW, 400 V, 1 phase, 50 Hz, 18-4.7 A, soft start; NumberOfStopsMaximum: 3; OverallDimensionsDepthMaximum: 1305 mm; OverallDimensionsWidthMaximum: 1190 mm; PlatformSizeOptions: 900 x 1040 mm, 900 x 1280 mm, 900 x 1480 mm, 1000 x 1280 mm, 1000 x 1480 mm, 1000 x 1980 mm, 1100 x 1480 mm, 1100 x 1580 mm; Ramp: 50 mm pit with optional ramp; RatedSpeed: 0.15 m/s; SafetyEdges: To three sides of platform and to top edge of console; SafeWorkingLoadMinimum: 410 kg; TravelHeightRange: 250-13000 mm; UserGroup: Ambulant and wheelchair users
Type - Pset_TransportElementCommon - FireExit: no; Reference: n/a
Type - Pset_TransportElementElevator - ClearDepth: 900 mm; ClearHeight: 0 mm; ClearWidth: 1040 mm
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 2200; HasProtectiveEarth: yes; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 20; NominalFrequencyRange: 50 Hz; NominalVoltage: 400; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 4.7
Type - COBie - AccessibilityPerformance: To relevant parts of building regulations Part M; AssetType: Fixed; Category: Generic Models; CodePerformance: To BS 6440, BS8300 and ISO 9386-1; Color: White, grey, natural metal; Constituents: n/a; Description: Short distance interior platform lift with through car entry and exit doors; DurationUnit: year; ExpectedLife: 20 years +; Features: Range of platform sizes an arrangments available, glazed shaft options, ideal for schools, retail and offices; Finish: Powder coated; Grade: n/a; Manufacturer: sales@gartec.com; Material: n/a; ModelNumber: n/a; ModelReference: Artico 7000 Platform Lift Through Car Entry and Exit Doors Short Travel Distance; Name: VerticalLiftingPlatforms_Artico7000PlatformLift_ThroughCarDoors-ShortTravelDistance-900x1040mm_GartecLtd; NominalHeight: 13000 mm; NominalLength: 900 mm; NominalWidth: 1040 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 1040 x 900 mm platform; SustainabilityPerformance: Materials are 95% recyclable, long design life, small carbon foorprint; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
